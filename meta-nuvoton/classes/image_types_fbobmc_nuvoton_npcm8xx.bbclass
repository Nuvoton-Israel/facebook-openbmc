../../yocto/lf-master/meta-phosphor/classes/image_types_phosphor_nuvoton_npcm8xx.bbclass