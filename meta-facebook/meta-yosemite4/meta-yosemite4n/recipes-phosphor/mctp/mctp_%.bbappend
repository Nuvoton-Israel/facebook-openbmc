FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0505-Support-to-apply-mctp-i2c-and-mctp-i3c-information.patch"
