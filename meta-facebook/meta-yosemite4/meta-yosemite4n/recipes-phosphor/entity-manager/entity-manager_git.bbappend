FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0006-configuration-yv4-set-mctp-i3c-information-for-SD-an.patch \
    file://0001-configuration-yosemite4n-add-support-2nd-source-ADC.patch \
"
