EXTRA_OECONF:append = " DEFAULT_INTF=obmc "
